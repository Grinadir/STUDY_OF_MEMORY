# IAR project STUDY_OF_MEMORY.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: C:\Users\Alexsandr\Desktop\IAR_PROJECT\STM8L_DISCOVERY_KIT\STUDY_OF_MEMORY\inc; C:\Users\Alexsandr\Desktop\IAR_PROJECT\STM8L_DISCOVERY_KIT\STUDY_OF_MEMORY\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STUDY_OF_MEMORY.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
